Commit message: new training. setup urdf again. initial pos changed. end effector link added

File: urdf_files/6dof/urdf/gen3_6dof.urdf (robot description, URDF)
Before this commit: robot gen3, 13 links, 12 joints
Links:
- link end_effector_link: mass None -> 0.001
